FILESEXTRAPATHS:prepend := "${THISDIR}/linux-imx:"
SRC_URI += "file://coredump.cfg"
